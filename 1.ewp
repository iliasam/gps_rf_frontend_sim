# IAR project 1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD_VL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; src\; src\inc\; StdPeriphLib\inc\; StdPeriphLib\src\; startup\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 1.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: D:\MYPROGS\DIY_GPS\SIMULATOR\simulator_fw\stm32f103c8t6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: init_periph.c main.c simulator.c stm32f10x_it.c
  group src
    src/: system_stm32f10x.c
  group src/inc
    src/inc/: config.h init_periph.h stm32f10x.h stm32f10x_it.h system_stm32f10x.h
  group src/startup
    ./: startup_stm32f103xb.s
  group StdPeriphLib/inc
    StdPeriphLib/inc/: stm32f10x_conf.h stm32f10x_dma.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_spi.h
  group StdPeriphLib/src
    StdPeriphLib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
